options:
  parameters:
    generate_options: qt_gui
    id: prbs_test
    output_language: python
    title: prbs source test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: prbs_bert_sink_b_0
  id: prbs_bert_sink_b
  parameters:
    g_data_invert: '0'
    g_meas_per_sec: '1'
    g_pn_sel: '2'
    g_samp_rate: samp_rate
    g_sync_bits: '512'
    g_total_bits: '10000'
  states: {}
- name: prbs_prbs_source_b_0
  id: prbs_prbs_source_b
  parameters:
    g_data_invert: '0'
    g_intent_err_rate: '0.01'
    g_pn_sel: '2'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '128'
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_int_to_float_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [prbs_prbs_source_b_0, '0', blocks_int_to_float_0, '0']
- [prbs_prbs_source_b_0, '0', prbs_bert_sink_b_0, '0']

metadata:
  file_format: 1
